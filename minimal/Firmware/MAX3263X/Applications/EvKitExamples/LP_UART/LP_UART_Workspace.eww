<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rx\IAR\LP_UART_RX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tx\IAR\LP_UART_TX.ewp</path>
  </project>
  <batchBuild/>
</workspace>


