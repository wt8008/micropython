# IAR project Peripheral.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32625 Maxim MAX32625
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR_SPIX_PRAGMA=1; TARGET=MAX32625; TARGET_REV=0x4132
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Libraries\Boards\Include; ..\..\..\..\Libraries\Boards\EvKit_V1\Include; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX32625\Include; ..\..\..\..\Libraries\MAX32625PeriphDriver\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Peripheral.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Libraries/MAX32625PeriphDriver/Source/: adc.c aes.c clkman.c crc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c maa.c mxc_assert.c mxc_sys.c nvic_table.c owm.c pmu.c prng.c pt.c rtc.c spim.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
  group BSP
    ../../../../Libraries/Boards/Source/: led.c max14690.c mx25.c nhd12832.c pb.c stdio.c
  group CMSIS
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32625/Source/IAR/: cmain.s low_level_init.c startup_max32625.s
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32625/Source/: system_max32625.c
