# Keil uVision project SPIM_MX25.uvprojx, settings and files
target Flash Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MAX32625 Maxim
  pack: Maxim.MAX32625.0.0.0-1.alpha
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPIM_MX25
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0, BSP:Board Support , Communications:I2C Master , Communications:SPI Master , Communications:UART , Device:Startup , HAL:Hardware Access Layer , Peripherals:GPIO 
