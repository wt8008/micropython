# IAR project LP_WakeupTime.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX3263x MAX3263x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR_SPIX_PRAGMA=1; TARGET=MAX3263x; BOARD=EvKit_V1; TARGET_REV=0x4132
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Libraries\Boards\Include; ..\..\..\..\Libraries\Boards\EvKit_V1\Include; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX3263x\Include; ..\..\..\..\Libraries\MAX3263xPeriphDriver\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LP_WakeupTime.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group BSP
    ../../../../Libraries/Boards/EvKit_V1/Source/: board.c
    ../../../../Libraries/Boards/Source/: led.c max14690.c mx25.c nhd12832.c pb.c stdio.c
  group CMSIS
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263x/Source/IAR/: startup_MAX3263x.s
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263x/Source/: system_MAX3263x.c
  group HAL
    ../../../../Libraries/MAX3263xPeriphDriver/Source/: adc.c aes.c clkman.c crc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c mxc_assert.c mxc_sys.c nvic_table.c pmu.c prng.c pt.c rtc.c spim.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
  group IAR
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263x/Source/IAR/: cmain.s low_level_init.c
