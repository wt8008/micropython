# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32620 Maxim MAX32620
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MXC_ASSERT_ENABLE
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Libraries\Boards\Include; ..\..\..\..\Libraries\Boards\EvKit_V1\Include; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX32620\Include; ..\..\..\..\Libraries\MAX32620PeriphDriver\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Maxim\MAX32620\MAX32620A.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group BSP
    ../../../../Libraries/Boards/EvKit_V1/Source/: board.c
    ../../../../Libraries/Boards/Source/: led.c max14690.c nhd12832.c stdio.c
  group CMSIS
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32620/Source/IAR/: startup_max32620.s
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32620/Source/: system_max32620.c
  group HAL
    ../../../../Libraries/MAX32620PeriphDriver/Source/: clkman.c gpio.c i2cm.c ioman.c lp.c mxc_sys.c spim.c tmr.c tmr_utils.c uart.c
    ../../../../Libraries/Boards/Source/: pb.c
  group IAR
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32620/Source/IAR/: cmain.s low_level_init.c
